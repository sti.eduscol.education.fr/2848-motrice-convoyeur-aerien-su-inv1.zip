# Autodesk Inventor assembly: cotg_Dfaut
## iProperties
Created: 2007-07
Part Number: cotg_Dfaut
Document SubType Name: Assembly
Designer: EF
Author: EF
