# Autodesk Inventor assembly: Assemblage vissé
## iProperties
ClientObjectVersion: 1
Created: 2007-07
Part Number: Assemblage vissé
Document SubType Name: Assembly
Designer: EF
Author: EF
