# Autodesk Inventor assembly: Ensemble fixe
## iProperties
Created: 2007-07
Part Number: Ensemble fixe
Document SubType Name: Assembly
Designer: EF
Author: EF
